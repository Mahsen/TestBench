# Keil uVision project main.uvproj, settings and files
target Main (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L152ZD STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: main +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32L1XX_HD
  c include: .\Application;.\Class;.\Peripherals\include;.\Config;.\Core;.\Drivers;.\Library;.\Main;.\RTX;.\Modules
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Main
    ./Main/: main.cpp
  group Application
    ./Application/: TestBench.cpp
  group Module
    ./Modules/: UI.cpp
  group Class
    ./Class/: DateType.cpp Media.cpp TagBench.cpp dap.c
  group Drivers
    ./Drivers/: adc.cpp gpio.cpp spi.cpp timer.cpp uart.cpp wdt.cpp pwm.cpp eeprom.cpp rtc.cpp TaskManager.cpp TaskTimer.cpp
  group Core
    ./Core/: core_cm3.c system_stm32l1xx.c startup_stm32l1xx_hd.s
  group Config
    ./Config/: RTX_Conf_CM.c Wizards.cpp
  group Peripherals
    ./Peripherals/source/: misc.c stm32l1xx_adc.c stm32l1xx_gpio.c stm32l1xx_rtc.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_rcc.c stm32l1xx_exti.c stm32l1xx_iwdg.c stm32l1xx_pwr.c stm32l1xx_spi.c stm32l1xx_flash.c stm32l1xx_syscfg.c
  group Library
    ./Library/: RTX_CM3.lib
